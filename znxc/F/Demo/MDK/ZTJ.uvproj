# Keil uVision project ZTJ.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: ZTJ +hex
  link misc: REMOVEUNUSED
  group code
    ../CODE/: dir.c dir.h adc.c adc.h state.c state.h action.c action.h speed.c speed.h ips114.c ips114.h pid.c pid.h encode.c encoder.h imu660.c imu660.h eeprom.c eeprom.h sys.h
  group user
    ../USER/: main.c isr.c isr.h main.h
  group zf_app
    ../../lib/zf_app/: board.c common.c board.h common.h
  group zf_base
    ../../lib/zf_base/: zf_adc.c zf_delay.c zf_eeprom.c zf_exti.c zf_fifo.c zf_gpio.c zf_iic.c zf_mdu16.c zf_nvic.c zf_pwm.c zf_spi.c zf_tim.c zf_uart.c STC32Gxx.h zf_adc.h zf_delay.h zf_eeprom.h zf_exti.h zf_fifo.h zf_gpio.h zf_iic.h zf_mdu16.h zf_nvic.h zf_pwm.h zf_spi.h zf_tim.h zf_uart.h
  group zf_bsp
    ../../lib/zf_bsp/: SEEKFREE_18TFT.c SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_AT24C02.c SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_DL1A.c SEEKFREE_FONT.c SEEKFREE_ICM20602.c SEEKFREE_IMU660RA.c SEEKFREE_IMU963RA.c SEEKFREE_IPS114_SPI.c SEEKFREE_MPU6050.c SEEKFREE_OLED.c SEEKFREE_PRINTF.c SEEKFREE_TSL1401.c SEEKFREE_VIRSCO.c SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS_CH573.c headfile.h SEEKFREE_18TFT.h SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_AT24C02.h SEEKFREE_BLUETOOTH_CH9141.h SEEKFREE_CONFIG.h SEEKFREE_DL1A.h SEEKFREE_FONT.h SEEKFREE_ICM20602.h SEEKFREE_IMU660RA.h SEEKFREE_IMU963RA.h SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.h SEEKFREE_OLED.h SEEKFREE_PRINTF.h SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.h SEEKFREE_WIRELESS_CH573.h SEEKFREE_CONFIG.LIB SEEKFREE_DL1B.c SEEKFREE_DL1B.h
